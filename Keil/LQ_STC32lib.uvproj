# Keil uVision project LQ_STC32lib.uvproj, settings and files
target LQ_Lib (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LQ_STC32lib +hex
  asm include: .\LQ_lib\app
  link misc: REMOVEUNUSED
  group APP
    ./LQ_lib/app/: LQ_GPIO_LED.c LQ_GPIO_KEY.c LQ_OLED096.c LQ_IIC_Gyro.c LQ_SPI_Gyro.c LQ_IIC_VL53.c LQ_CCD.c
    ./LQ_lib/driver/: ANO_DT.c
  group drv
    ./LQ_lib/driver/: LQ_UART.c LQ_Encoder.c LQ_TIMER.c LQ_MotorServo.c LQ_ADC.c LQ_GPIO_EXIT.c LQ_SPI_soft.c LQ_SOFTI2C.c stc32g128.h
  group user
    ./user/: main.c include.h
